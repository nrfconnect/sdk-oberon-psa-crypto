# Keil uVision project SpeedM4.uvprojx, settings and files
target M4 Sim TinyCrypt (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TestM4-Oberon-PSA-Crypto
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT
  c include: ..\include;..\M4F;..\..\..\..\tinycrypt\lib\include;..\..\..\..\tinycrypt-sha512\lib\include;..\..\..\include;..\..\..\oberon\platforms\demo\include
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group System Files
    ./: startup_ARMCM4.s system_ARMCM4.c Retarget.c
  group Test Files
    ../: cycle_test.c cycle_test_ocrypto.c cycle_test_tinycrypt.c
  group OberonCrypto
    ../../../../OberonCrypto/src/: ocrypto_aes_cbc.c ocrypto_aes_cbc_pkcs.c ocrypto_aes_ccm.c ocrypto_aes_cmac.c ocrypto_aes_ctr.c ocrypto_aes_eax.c ocrypto_aes_ecb.c ocrypto_aes_gcm.c ocrypto_aes_key_wrap.c ocrypto_ascon_aead.c ocrypto_ascon_hash.c ocrypto_chacha20.c ocrypto_chacha20_poly1305.c ocrypto_curve_p224.c ocrypto_curve_p256.c ocrypto_curve_p256k1.c ocrypto_curve_p384.c ocrypto_curve_p521.c ocrypto_curve448.c ocrypto_curve25519.c ocrypto_ecdh_p224.c ocrypto_ecdh_p256.c ocrypto_ecdh_p256k1.c ocrypto_ecdh_p384.c ocrypto_ecdh_p521.c ocrypto_ecdsa_p224.c ocrypto_ecdsa_p256.c ocrypto_ecdsa_p256_det_sign.c ocrypto_ecdsa_p256k1.c ocrypto_ecdsa_p384.c ocrypto_ecdsa_p521.c ocrypto_ecjpake_p256.c ocrypto_ed448.c ocrypto_ed25519.c ocrypto_ge448.c ocrypto_ge25519.c ocrypto_hkdf_sha1.c ocrypto_hkdf_sha256.c ocrypto_hkdf_sha512.c ocrypto_hmac_sha1.c ocrypto_hmac_sha256.c ocrypto_hmac_sha512.c ocrypto_lms_sha256.c ocrypto_lms_shake256.c ocrypto_mod_p224.c ocrypto_mod_p256.c ocrypto_mod_p256k1.c ocrypto_mod_p384.c ocrypto_mod_p521.c ocrypto_mod448.c ocrypto_mod25519.c ocrypto_pbkdf2_cmac_prf128.c ocrypto_pbkdf2_sha1.c ocrypto_pbkdf2_sha256.c ocrypto_poly1305.c ocrypto_rsa_operations.c ocrypto_rsa_padding.c ocrypto_rsa_primitives.c ocrypto_rsa1024.c ocrypto_rsa2048.c ocrypto_sc_p224.c ocrypto_sc_p256.c ocrypto_sc_p256k1.c ocrypto_sc_p384.c ocrypto_sc_p521.c ocrypto_sc448.c ocrypto_sc25519.c ocrypto_sha1.c ocrypto_sha3.c ocrypto_sha256.c ocrypto_sha512.c ocrypto_spake2p_p256.c ocrypto_srp.c ocrypto_srp_math.c ocrypto_srtp.c ocrypto_wideint_inv.c ocrypto_wideint_mul.c ocrypto_wpa3_sae_p256.c ocrypto_ml_dsa_hash.c ocrypto_ml_dsa_math.c ocrypto_ml_dsa44.c ocrypto_ml_dsa65.c ocrypto_ml_dsa87.c ocrypto_ml_kem_hash.c ocrypto_ml_kem512.c ocrypto_ml_kem768.c ocrypto_ml_kem1024.c
  group OberonCrypto Generic
    ../../../../OberonCrypto/src/platforms/Generic/: ocrypto_aes.c ocrypto_aes_dec.c ocrypto_ascon_loop.c ocrypto_bigint128.c ocrypto_bigint192.c ocrypto_bigint224.c ocrypto_bigint256.c ocrypto_bigint384.c ocrypto_bigint448.c ocrypto_bigint521.c ocrypto_chacha20_loop.c ocrypto_constant_time.c ocrypto_gf128_mul.c ocrypto_load_store.c ocrypto_mod_p224_base.c ocrypto_mod_p256_base.c ocrypto_mod_p256k1_base.c ocrypto_mod_p384_base.c ocrypto_mod_p521_base.c ocrypto_mod448_base.c ocrypto_mod25519_base.c ocrypto_poly1305_mul.c ocrypto_sha3_loop.c ocrypto_sha256_loop.c ocrypto_sha512_loop.c ocrypto_wideint.c
  group OberonCrypto M4F
    ../../../../OberonCrypto/src/platforms/M4F/ARM/: ocrypto_aes.s ocrypto_aes_dec.s ocrypto_ascon_loop.s ocrypto_bigint128.s ocrypto_bigint192.s ocrypto_bigint224.s ocrypto_bigint256.s ocrypto_bigint384.s ocrypto_bigint448.s ocrypto_bigint521.s ocrypto_chacha20_loop.s ocrypto_constant_time.s ocrypto_gf128_mul.s ocrypto_mod_p224_base.s ocrypto_mod_p256_base.s ocrypto_mod_p256k1_base.s ocrypto_mod_p384_base.s ocrypto_mod_p521_base.s ocrypto_mod448_base.s ocrypto_mod25519_base.s ocrypto_poly1305_mul.s ocrypto_sha3_loop.s ocrypto_sha256_loop.s ocrypto_sha512_loop.s ocrypto_wideint.s ocrypto_ml_dsa_math_base.s ocrypto_ml_kem_math_base.s
  group Oberon PSA Crypto Config
    ../include/mbedtls/: mbedtls_config.h
  group Oberon PSA Crypto
    ../../../oberon/drivers/: oberon_helpers.c oberon_aead.c oberon_asymmetric_encrypt.c oberon_asymmetric_signature.c oberon_cipher.c oberon_ctr_drbg.c oberon_ec_keys.c oberon_ecdh.c oberon_ecdsa.c oberon_hash.c oberon_hmac_drbg.c oberon_jpake.c oberon_key_agreement.c oberon_key_derivation.c oberon_key_management.c oberon_key_wrap.c oberon_mac.c oberon_pake.c oberon_rsa.c oberon_spake2p.c oberon_srp.c oberon_wpa3_sae.c oberon_lms.c oberon_xmss.c oberon_eddsa.c oberon_key_encapsulation.c oberon_ml_dsa.c oberon_ml_kem.c oberon_xof.c
    ../../../platform/: platform.c platform_util.c
    ../../../core/: psa_crypto.c psa_crypto_client.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c
    ../../../oberon/platforms/demo/library/: psa_crypto_driver_wrappers.c
    ../../../oberon/platforms/demo/drivers/: demo_entropy.c demo_hardware.c demo_opaque.c
    ../../../utilities/: constant_time.c
  group TF-PSA-Crypto Config
    ../tf-psa-crypto/psa/: crypto_config.h
  group TF-PSA-Crypto
    ../../../../TF-PSA-Crypto/core/: psa_crypto.c psa_crypto_client.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c
    ../../../../TF-PSA-Crypto/legacy_sub/src/: aes.c aesce.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c des.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c entropy.c entropy_poll.c gcm.c hkdf.c hmac_drbg.c lmots.c lms.c md.c md5.c memory_buffer_alloc.c nist_kw.c oid.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha3.c sha256.c sha512.c threading.c
  group TF-PSA-Crypto Custom
    ../tf-psa-crypto/: psa_crypto_driver_wrappers_no_static.c minimal_rng.c
  group TinyCrypt
    ../../../../tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dh.c ecc_dsa.c ecc_platform_specific.c hmac.c hmac_prng.c sha256.c utils.c
    ../../../../tinycrypt-sha512/lib/source/: sha512.c
target M4 Sim ocrypto Generic (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: as above
  output: TestM4-ocrypto
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT
  c include: ..\include;..\..\..\include;..\..\..\core;..\..\..\oberon\drivers;..\..\..\oberon\platforms\demo\include;..\..\..\oberon\platforms\demo\drivers;..\M4F;..\..\..\..\OberonCrypto\include;..\..\..\..\OberonCrypto\src;..\..\..\..\OberonCrypto\src\platforms\Generic
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target M4 Sim ocrypto M4F (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: as above
  output: TestM4-ocrypto
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT
  c include: ..\include;..\..\..\include;..\..\..\core;..\..\..\oberon\drivers;..\..\..\oberon\platforms\demo\include;..\..\..\oberon\platforms\demo\drivers;..\M4F;..\..\..\..\OberonCrypto\include;..\..\..\..\OberonCrypto\src;..\..\..\..\OberonCrypto\src\platforms\M4F
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target M4 Sim Oberon PSA Crypto (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: as above
  output: TestM4-Oberon-PSA-Crypto
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT
  c include: ..\include;..\..\..\include;..\..\..\core;..\..\..\dispatch;..\..\..\extras;..\..\..\platform;..\..\..\utilities;..\..\..\oberon\drivers;..\..\..\oberon\platforms\demo\include;..\..\..\oberon\platforms\demo\drivers;..\M4F;..\..\..\..\OberonCrypto\include;..\..\..\..\OberonCrypto\src;..\..\..\..\OberonCrypto\src\platforms\M4F
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target M4 Sim TF-PSA-Crypto (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: as above
  output: TestM4
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT
  c include: ..\tf-psa-crypto;..\M4F;..\..\..\..\TF-PSA-Crypto\include;..\..\..\..\TF-PSA-Crypto\legacy_sub\include;..\..\..\..\TF-PSA-Crypto\legacy_sub\src;..\..\..\..\TF-PSA-Crypto\core
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
software components: CMSIS:CORE 6.0.0
