# Keil uVision project SpeedM0.uvprojx, settings and files
target M0 Simulator (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TestM0
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\include;..\..\..\tests;..\..\..\include;..\..\..\core;..\..\..\dispatch;..\..\..\extras;..\..\..\platform;..\..\..\utilities;..\..\..\oberon\drivers;..\..\..\oberon\platforms\demo\include;..\..\..\oberon\platforms\demo\drivers;..\M0;..\..\..\..\OberonCrypto\include;..\..\..\..\OberonCrypto\src;..\..\..\..\OberonCrypto\src\platforms\M0
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group System Files
    ./: startup_ARMCM0.s system_ARMCM0.c Retarget.c
  group Test Files
    ../: cycle_test.c
  group Crypto
    ../../../../OberonCrypto/src/: ocrypto_aes_cbc.c ocrypto_aes_cbc_pkcs.c ocrypto_aes_ccm.c ocrypto_aes_cmac.c ocrypto_aes_ctr.c ocrypto_aes_eax.c ocrypto_aes_ecb.c ocrypto_aes_gcm.c ocrypto_aes_key_wrap.c ocrypto_ascon_aead.c ocrypto_ascon_hash.c ocrypto_chacha20.c ocrypto_chacha20_poly1305.c ocrypto_curve_p224.c ocrypto_curve_p256.c ocrypto_curve_p256k1.c ocrypto_curve_p384.c ocrypto_curve_p521.c ocrypto_curve448.c ocrypto_curve25519.c ocrypto_ecdh_p224.c ocrypto_ecdh_p256.c ocrypto_ecdh_p256k1.c ocrypto_ecdh_p384.c ocrypto_ecdh_p521.c ocrypto_ecdsa_p224.c ocrypto_ecdsa_p256.c ocrypto_ecdsa_p256_det_sign.c ocrypto_ecdsa_p256k1.c ocrypto_ecdsa_p384.c ocrypto_ecdsa_p521.c ocrypto_ecjpake_p256.c ocrypto_ed448.c ocrypto_ed25519.c ocrypto_ge448.c ocrypto_ge25519.c ocrypto_hkdf_sha1.c ocrypto_hkdf_sha256.c ocrypto_hkdf_sha512.c ocrypto_hmac_sha1.c ocrypto_hmac_sha256.c ocrypto_hmac_sha512.c ocrypto_lms_sha256.c ocrypto_lms_shake256.c ocrypto_mod_p224.c ocrypto_mod_p256.c ocrypto_mod_p256k1.c ocrypto_mod_p384.c ocrypto_mod_p521.c ocrypto_mod448.c ocrypto_mod25519.c ocrypto_pbkdf2_cmac_prf128.c ocrypto_pbkdf2_sha1.c ocrypto_pbkdf2_sha256.c ocrypto_poly1305.c ocrypto_rsa_operations.c ocrypto_rsa_padding.c ocrypto_rsa_primitives.c ocrypto_rsa1024.c ocrypto_rsa2048.c ocrypto_sc_p224.c ocrypto_sc_p256.c ocrypto_sc_p256k1.c ocrypto_sc_p384.c ocrypto_sc_p521.c ocrypto_sc448.c ocrypto_sc25519.c ocrypto_sha1.c ocrypto_sha3.c ocrypto_sha256.c ocrypto_sha512.c ocrypto_spake2p_p256.c ocrypto_srp.c ocrypto_srp_math.c ocrypto_srtp.c ocrypto_wideint_inv.c ocrypto_wideint_mul.c ocrypto_wpa3_sae_p256.c ocrypto_xmss_sha256.c ocrypto_xmss_shake256.c ocrypto_ml_dsa_hash.c ocrypto_ml_dsa_math.c ocrypto_ml_dsa44.c ocrypto_ml_dsa65.c ocrypto_ml_dsa87.c ocrypto_ml_kem_hash.c ocrypto_ml_kem512.c ocrypto_ml_kem768.c ocrypto_ml_kem1024.c
    ../../../../OberonCrypto/src/platforms/M0/ARM/: ocrypto_aes.s ocrypto_aes_dec.s ocrypto_ascon_loop.s ocrypto_bigint128.s ocrypto_bigint192.s ocrypto_bigint224.s ocrypto_bigint256.s ocrypto_bigint384.s ocrypto_bigint448.s ocrypto_bigint521.s ocrypto_chacha20_loop.s ocrypto_constant_time.s ocrypto_gf128_mul.s ocrypto_load_store.s ocrypto_mod_p224_base.s ocrypto_mod_p256_base.s ocrypto_mod_p256k1_base.s ocrypto_mod_p384_base.s ocrypto_mod_p521_base.s ocrypto_mod448_base.s ocrypto_mod25519_base.s ocrypto_poly1305_mul.s ocrypto_sha3_loop.s ocrypto_sha256_loop.s ocrypto_sha512_loop.s ocrypto_wideint.s ocrypto_ml_dsa_math_base.s ocrypto_ml_kem_math_base.s
  group PSA
    ../../../oberon/drivers/: oberon_aead.c oberon_asymmetric_encrypt.c oberon_asymmetric_signature.c oberon_cipher.c oberon_ctr_drbg.c oberon_ec_keys.c oberon_ecdh.c oberon_ecdsa.c oberon_hash.c oberon_helpers.c oberon_hmac_drbg.c oberon_jpake.c oberon_key_agreement.c oberon_key_derivation.c oberon_key_management.c oberon_key_wrap.c oberon_lms.c oberon_mac.c oberon_pake.c oberon_rsa.c oberon_spake2p.c oberon_srp.c oberon_wpa3_sae.c oberon_xmss.c oberon_eddsa.c oberon_ml_dsa.c oberon_ml_kem.c oberon_key_encapsulation.c oberon_xof.c
    ../../../utilities/: constant_time.c
    ../../../platform/: platform.c platform_util.c threading.c
    ../../../core/: psa_crypto.c psa_crypto_client.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c
    ../../../oberon/platforms/demo/drivers/: demo_entropy.c demo_hardware.c demo_opaque.c
    ../../../oberon/platforms/demo/library/: psa_crypto_driver_wrappers.c
software components: CMSIS:CORE 6.0.0
